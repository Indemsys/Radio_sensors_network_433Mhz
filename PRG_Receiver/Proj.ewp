# IAR project Proj.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m8 ATmega8
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: D:\Embedded\Projects\OpenSource\Radio_network_433Mhz\PRG_Receiver\lnkm8s.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: lcd.c main.c modbus.c Monitor.c rc4.c RF_receiver.c Timers.c USART.c Util.c wrk_params.c
